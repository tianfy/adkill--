## adkill/src/Kconfig
```kconfig
config ADKILL
　　tristate "Just a adkill"
　　help
　　　This is a adkill.
　　　If unsure, say N.
```
